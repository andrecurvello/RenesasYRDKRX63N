<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HelloWorld\HelloWorld.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SimpleBlinkingLED\SimpleBlinkingLED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SimpleBlinkingLED_Simpler\SimpleBlinkingLED_Simpler.ewp</path>
  </project>
  <batchBuild/>
</workspace>


